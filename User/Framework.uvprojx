# Keil uVision project Framework.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Framework
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\User;..\Hardware;..\Dirvers;..\Core;..\Algorithm;..\OS\UCOSII;..\APP_Debug
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Algorithm
    ../Algorithm/: digitalFilter.c sequence.c kalmanFilter.c maximumValue.c pid.c
  group Core
    ../Core/: core_cm3.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_it.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c system_stm32f10x.c startup_stm32f10x_hd.s
  group Dirvers
    ../Dirvers/: delay.c gpio.c spi.c sys.c usart.c adc.c dac.c I2C.c timer.c
  group Hardware
    ../Hardware/: bluebooth.c oled.c exti.c oledfont.c attitude.c encoder.c motorDC.c motorStepper.c steeringGear.c
  group User
    ./: main.c
    ../APP_Debug/: show.c
  group OS
    ../OS/UCOSII/: os_core.c os_cpu_c.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c os_cpu_a.asm
